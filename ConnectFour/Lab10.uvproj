# Keil uVision project Lab10.uvproj, settings and files
target blinky (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S1968
  c include: ..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: blinky.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S Lab10.c
  group Libraries
    ./: driverlib-cm3.lib ECE210.lib
